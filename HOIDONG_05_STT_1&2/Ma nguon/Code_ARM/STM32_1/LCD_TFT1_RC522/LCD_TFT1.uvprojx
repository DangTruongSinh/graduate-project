# Keil uVision project LCD_TFT1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD_TFT1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Libraries\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c
  group lib
    ../Libraries/User/: Touch.c lcd.c 24C02.c stm32f10x_it.c spi.c rc522.c R305.c USART.c diskio.c ff.c SD_driver.c
    ../Libraries/User/ds1307/: ds1307.c i2c.c
  group hinh
    ../Libraries/User/anh/: hinhnen.c password.c myanh.c r305_50_44.c
    ../Libraries/User/TV_ANH/: RFID.c
software components: CMSIS:CORE 5.2.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Data Exchange:JSON:cJSON 1.7.7, Data Exchange:JSON:parson 0.0.0
